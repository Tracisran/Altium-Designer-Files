# Keil uVision project 练习3.uvproj, settings and files
target Target 1 (MCS-51)
  device: IAP15F206A IAP15F204EA Series
  cpu: IRAM(0-0x7F) IROM(0-0x17F8) CLOCK(35000000)
  output: 练习3 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\练习3
  group Source Group 1
    ./: STARTUP.A51 练习3.c

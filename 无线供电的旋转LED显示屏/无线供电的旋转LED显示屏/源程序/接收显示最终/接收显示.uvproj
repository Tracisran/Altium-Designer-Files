# Keil uVision project 接收显示.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC89C51RC Series
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 接收显示 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\24L01;.\ziku;.\AT24C64;..\接收显示
  group Source Group 1
    ./: STARTUP.A51 接收练习.c syste.c
    ./24L01/: 24L01.c
    ./AT24C64/: 24C64.C
